<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\_prj_MKI109V3.ewp</path>
  </project>
  <batchBuild />
</workspace>
