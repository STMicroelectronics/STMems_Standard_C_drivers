# IAR project _prj_MKI109V3.ewp, settings and files
configuration _prj_MKI109V3 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401VE ST STM32F401VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; STEVAL_MKI109V3
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; C:\Users\visconta\Projects\STdC\iis3dhhc_STdC\driver; C:\Users\visconta\Projects\STdC\iis3dwb_STdC\driver; C:\Users\visconta\Projects\STdC\iis3dwb10is_STdC\driver; C:\Users\visconta\Projects\STdC\asm9g300b_STdC\driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: _prj_MKI109V3.bin
  ILINK.IlinkOutputFile: _prj_MKI109V3.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: gpio.c i2c.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group asm9g300b
    ../../asm9g300b_STdC/examples/: asm9g300b_read.c
    ../../asm9g300b_STdC/driver/: asm9g300b_reg.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group iis3dwb
    ../../iis3dwb_STdC/examples/: iis3dwb_fifo.c iis3dwb_read_data_polling.c
    ../../iis3dwb_STdC/driver/: iis3dwb_reg.c
  group iis3dwb10is
    ../../iis3dwb10is_STdC/examples/: iis3dwb10is_fifo_read.c iis3dwb10is_fifo_read_low_power.c iis3dwb10is_read_data.c iis3dwb10is_read_data_16b.c
    ../../iis3dwb10is_STdC/driver/: iis3dwb10is_reg.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
