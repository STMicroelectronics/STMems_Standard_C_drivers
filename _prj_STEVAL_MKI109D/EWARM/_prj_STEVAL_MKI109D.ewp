# IAR project _prj_STEVAL_MKI109D.ewp, settings and files
configuration _prj_STEVAL_MKI109D (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H563xx; STEVAL_MKI109D
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32H5xx_HAL_Driver/Inc; ../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../Drivers/CMSIS/Include; ../Middleware/USB/stm32-mw-usb-device/Core/Inc; ../Middleware/USB/stm32-mw-usb-device/Class/CDC/Inc; ../Middleware/USB/Device/Core/Inc; ../Middleware/USB/Device/Class/CDC/Inc; C:\Users\visconta\Projects\STdC\lsm6dsv16x_STdC\driver; C:\Users\visconta\Projects\STdC\_resources\st-mems-finite-state-machine\examples\glance_detection\lsm6dsv16x; C:\Users\visconta\Projects\STdC\_resources\st-mems-finite-state-machine\examples\fourd_orientation_detection\lsm6dsv16x; C:\Users\visconta\Projects\STdC\_resources\st-mems-machine-learning-core\examples\gym_activity_recognition\lsm6dsv16x; C:\Users\visconta\Projects\STdC\lis2mdl_STdC\driver; C:\Users\visconta\Projects\STdC\lps22df_STdC\driver; C:\Users\visconta\Projects\STdC\iis3dwb_STdC\driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: _prj_STEVAL_MKI109D.bin
  ILINK.IlinkOutputFile: _prj_STEVAL_MKI109D.out
  ILINK.IlinkIcfFile: stm32h563xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h563xx.s
  group Application/User/Core
    ../Core/Src/: board.c dac.c gpdma.c gpio.c i2c.c i3c.c icache.c main.c queue.c sai.c spi.c stm32h5xx_hal_msp.c stm32h5xx_it.c tim.c usart.c usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dac.c stm32h5xx_hal_dac_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_i3c.c stm32h5xx_hal_icache.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_sai.c stm32h5xx_hal_sai_ex.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_ll_usb.c stm32h5xx_util_i3c.c
  group mems-drivers/iis3dwb
    ../../iis3dwb_STdC/examples/: iis3dwb_fifo.c iis3dwb_read_data_polling.c iis3dwb_self_test.c iis3dwb_wake_up.c
    ../../iis3dwb_STdC/driver/: iis3dwb_reg.c
  group mems-drivers/lsm6dsv16x
    ../../lsm6dsv16x_STdC/examples/: lsm6dsv16x_fifo.c lsm6dsv16x_fifo_irq.c lsm6dsv16x_fifo_stepcnt.c lsm6dsv16x_free_fall.c lsm6dsv16x_fsm_fourd.c lsm6dsv16x_fsm_glance.c lsm6dsv16x_mlc_gym.c lsm6dsv16x_pedometer.c lsm6dsv16x_qvar_read_data_polling.c lsm6dsv16x_read_data_irq.c lsm6dsv16x_read_data_polling.c lsm6dsv16x_self_test.c lsm6dsv16x_sensor_fusion.c lsm6dsv16x_sensor_hub.c lsm6dsv16x_sig_mot.c lsm6dsv16x_single_double_tap.c lsm6dsv16x_six_d_position.c lsm6dsv16x_tilt.c lsm6dsv16x_wakeup.c
    ../../lsm6dsv16x_STdC/driver/: lsm6dsv16x_reg.c
  group Middleware/USB/Device/Class/CDC/Inc
    ../Middleware/USB/Device/Class/CDC/Inc/: usbd_cdc_if.h
  group Middleware/USB/Device/Class/CDC/Src
    ../Middleware/USB/Device/Class/CDC/Src/: usbd_cdc_if.c
  group Middleware/USB/Device/Core/Inc
    ../Middleware/USB/Device/Core/Inc/: usb_device.h usbd_conf.h usbd_desc.h
  group Middleware/USB/Device/Core/Src
    ../Middleware/USB/Device/Core/Src/: usb_device.c usbd_conf.c usbd_desc.c
  group Middleware/USB/stm32-mw-usb-device/Class/CDC/Inc
    ../Middleware/USB/stm32-mw-usb-device/Class/CDC/Inc/: usbd_cdc.h
  group Middleware/USB/stm32-mw-usb-device/Class/CDC/Src
    ../Middleware/USB/stm32-mw-usb-device/Class/CDC/Src/: usbd_cdc.c
  group Middleware/USB/stm32-mw-usb-device/Core/Inc
    ../Middleware/USB/stm32-mw-usb-device/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
  group Middleware/USB/stm32-mw-usb-device/Core/Src
    ../Middleware/USB/stm32-mw-usb-device/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
